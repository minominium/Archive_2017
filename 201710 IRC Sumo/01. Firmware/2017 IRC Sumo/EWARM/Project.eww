<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2017 IRC Sumo.ewp</path>
  </project>
  <batchBuild />
</workspace>
